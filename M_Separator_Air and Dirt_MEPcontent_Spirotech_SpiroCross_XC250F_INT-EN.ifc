Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: f3a51646-a1de-4539-a2f9-f600db158adc, NumberOfSaves: 173]
File name: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCross_XC250F_INT-EN.ifc
Time: 2025-08-05T18:33:38+02:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.60.36 (ENG) - IFC 23.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuildingStorey: Level:Floor Level (3)
Pset_BuildingStoreyCommon - Reference: Floor Level
Other - Category: Levels; Family: Level; Family and Type: Level: Floor Level; Type: Floor Level; Type Id: 305
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent : standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Floor Level
Name | LongName = Name | Elevation (mm) = Constraints, Elevation (mm)
F00 | F00 | 0
F01 | F01 | 3300
F02 | F02 | 6600

# IfcDistributionPort (4)
Description: Flow; FlowDirection: SOURCEANDSINK; PredefinedType: PIPE
Name
Port_2152123_3
Port_2152123_4
Port_2152123_7
Port_2152123_8

# IfcValve: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCross_XC_INT-EN:XC250F, M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCross_XC_INT-EN:XC250F:2152123
In: F00
Type - Material: Color RGB 198-000-000, Color RGB 128-128-128, Color RGB 168-128-048, Color RAL 1003
Type - Other - Category: Pipe Accessories; Base Flange: 22.5 mm; Base Flange Radius: 136.5 mm; Bottom Geomtry Height: 95 mm; Brackets Height: 20 mm; Chamfer Radius: 101.6 mm; Cone Flange: 28 mm; Cone Flange Radius Bottom: 158.5 mm; Cone Flange Radius Top: 136.5 mm; Connection Diameter: 250 mm; Distance Between Brackets: 408 mm; DN: 250 mm; Drain Height: 215 mm; Drain Offset: 174.5 mm; Drain Radius: 30.15 mm; Family Name: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCross_XC_INT-EN; Flange Body: 23 mm; Flange Body Radius: 202.5 mm; Flange Gasket: 3 mm; Flange Gasket Radius: 160 mm; Front Bracket Height: 410 mm; Front Bracket Offset: 2000 mm; Front Bracket Offset 2: 254 mm; h: 835 mm; H1: 465 mm; h2: 935 mm; h3: 215 mm; Inner Diameter Ring: 10 mm; OD: 273 mm; Outer Diameter Bracket: 64 mm; Type Value: 15; Upper Geometry Radius: 12 mm; Upper Side Height: 833 mm; Width: 656 mm
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - D: 508 mm; H: 2870 mm; L: 737 mm; LF: 890 mm; Use Nominal Diameter: yes
Type - Identity Data - Article Description: Low-loss Header with Deaerator & dirt separator - Steel - Flange DN250; Article Type: XC250F; Base Family Version: 25.09; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Low-loss Header with Deaerator & dirt separator - Steel - Flange DN250; EMCS Version: 4.0; ETIM Article Class: EC010260; Family Version: 12.05; GLN: 8717811000007; GTIN: 8717811015674; Manufacturer: Spirotech; Manufacturer Art. No.: XC250F; Manufacturer URL: https://www.spirotech.com/8717811015674; MEPcontent Class: SEPARATOR_AIR_AND_DIRT; Model: XC250F; OmniClass Number: 23.70.50.14.31; OmniClass Title: Liquid Waste Separators; Product Line: Spirotech; Revit Version: 2023; Type Name: XC250F; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Yellow: Color RAL 1003
Type - Mechanical - Capacity: 0 m3; Flow-through Capacity: 0 m3/s; Nominal Flow Rate: 0.08 m3/s; Pressure Stage: 16; Volume: 0.501 m3; Weight: 413 kg
Type - Mechanical - Flow - Pressure Drop: 6900 Pa
Type - Visibility - Flange: yes; Front Bracket: yes
Type - Pset_ManufacturerTypeInformation - Manufacturer: Spirotech
Pset_EnvironmentalImpactIndicators - Reference: XC250F; sets with these values: 2
Other - Bottom Clearance Safe: 100 mm; Connection Length: 890 mm; Connectors Length: 890 mm; Connectors Length Safe: 1002 mm; Family: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCross_XC_INT-EN; Family and Type: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCross_XC_INT-EN: XC250F; Length: 890 mm; Top Clearance Safe: 50 mm; Type: XC250F; Type Id: 2152076
Constraints - Actual Offset: 10 mm; Elevation from Level: 0 mm; Negative Offset: 10 mm
Dimensions - Area: 5.25276 m2; Maximum Size: 250 mm; Minimum Size: 250 mm; Volume: 0.610319 m3
Graphics - Annotation Offset RL: 0 mm
Identity Data - Mark: 11
Mechanical - System Classification: Undefined
Mechanical - Flow - Flow In: 0 m3/s; Flow In 2: 0 m3/s
Phasing - Phase Created: 3. New Construction
Visibility - Bottom Clearance: 100 mm; Counter Flange: no; Service Space: no; Top Clearance: 50 mm
Insulation - Insulation Thickness: 0 mm
